# Keil uVision project STM32F1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\startup;..\STM32F10x_StdPeriph_Driver\inc;..\user;..\user\api;..\user\SD_SDIO;..\user\FATFS\ff13a\source;..\user\AT24Cxx;..\user\SIM7600
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group device
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
  group api
    ../user/api/: usart.c can.c led.c key.c delay.c fun.c sys.c iic.c spi.c
  group SDIO
    ../user/SD_SDIO/: stm32_eval_sdio_sd.c stm3210e_eval.c new_add.c sdio_test.c
  group FATFS
    ../user/FATFS/ff13a/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group AT24Cxx
    ../user/AT24Cxx/: AT24Cxx.c
  group GPS_SIM7600CE-T
    ../user/SIM7600/: SIM7600.c
software components: CMSIS:CORE 5.2.0
